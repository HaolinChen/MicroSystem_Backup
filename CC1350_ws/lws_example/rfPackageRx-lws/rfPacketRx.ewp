# IAR project rfPacketRx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DeviceFamily_CC13X0; CCFG_FORCE_VDDR_HH=0; SUPPORT_PHY_CUSTOM; SUPPORT_PHY_50KBPS2GFSK; SUPPORT_PHY_625BPSLRM; SUPPORT_PHY_5KBPSSLLR
  ICCARM.IExtraOptions: -f$COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL_433/release/iar/compiler.opt.defs; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/posix/iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  prebuild: iarbuild.exe $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL_433/release/iar/tirtos_builds_CC1350_LAUNCHXL_433_release.ewp Debug -log all
  ILINK.IlinkOutputFile: rfPacketRx.out
  ILINK.IlinkIcfFile: $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/examples/rtos/CC1350_LAUNCHXL_433/drivers/rfPacketRx/tirtos/iar/CC1350_LAUNCHXL_433_TIRTOS.icf
  ILINK.IlinkExtraOptions: -f$COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL_433/release/iar/linker.cmd; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm3; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m3/grlib.a; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m3/spiffs_cc26xx.a; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc13x0.arm3; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc13x0.arm3; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/dpl/lib/dpl_cc13x0.arm3; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/devices/cc13x0/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group rfPacketRx/Documentation
    $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/boards/CC1350_LAUNCHXL_433/: Board.html
    ./: README.md
  group rfPacketRx/Header files
    ./: Board.h CC1350_LAUNCHXL_433.h RFQueue.h
    smartrf_settings/: smartrf_settings.h
  group rfPacketRx/Source files
    ./: CC1350_LAUNCHXL_433.c CC1350_LAUNCHXL_433_fxns.c CC1350_LAUNCHXL_433_TIRTOS.icf ccfg.c main_tirtos.c rfPacketRx.c RFQueue.c
    smartrf_settings/: smartrf_settings.c
