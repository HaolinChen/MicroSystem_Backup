# IAR project pwmled_lws.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DeviceFamily_CC13X0
  ICCARM.IExtraOptions: -f$SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL_433/release/iar/compiler.opt.defs; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/posix/iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: pwmled2.srec
  prebuild: iarbuild.exe $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL_433/release/iar/tirtos_builds_CC1350_LAUNCHXL_433_release.ewp Debug -log all
  ILINK.IlinkOutputFile: pwmled2.out
  ILINK.IlinkIcfFile: $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/examples/rtos/CC1350_LAUNCHXL_433/drivers/pwmled2/tirtos/iar/CC1350_LAUNCHXL_433_TIRTOS.icf
  ILINK.IlinkExtraOptions: -f$SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL_433/release/iar/linker.cmd; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m3/grlib.a; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m3/spiffs_cc26xx.a; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/dpl/lib/dpl_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/devices/cc13x0/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group pwmled2/Documentation
    $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/boards/CC1350_LAUNCHXL_433/: Board.html
    ./: README.html README.md
  group pwmled2/Header files
    ./: Board.h CC1350_LAUNCHXL_433.h
  group pwmled2/Source files
    ./: CC1350_LAUNCHXL_433.c CC1350_LAUNCHXL_433_fxns.c CC1350_LAUNCHXL_433_TIRTOS.icf ccfg.c main_tirtos.c pwmled2.c
