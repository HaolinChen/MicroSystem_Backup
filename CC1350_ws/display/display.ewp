# IAR project display.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_UART_ANSI=1; BOARD_DISPLAY_USE_LCD=1; DeviceFamily_CC13X0
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/nortos; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/nortos/posix
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  ILINK.IlinkOutputFile: display.out
  ILINK.IlinkIcfFile: $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/examples/nortos/CC1350_LAUNCHXL/drivers/display/iar/CC1350_LAUNCHXL_NoRTOS.icf
  ILINK.IlinkExtraOptions: $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m3/grlib.a; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m3/spiffs_cc26xx.a; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/nortos/lib/nortos_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/devices/cc13x0/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group display/Documentation
    $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/boards/CC1350_LAUNCHXL/: Board.html
    ./: README.html README.md
  group display/Header files
    ./: Board.h CC1350_LAUNCHXL.h splash_image.h
  group display/Source files
    ./: CC1350_LAUNCHXL.c CC1350_LAUNCHXL_fxns.c CC1350_LAUNCHXL_NoRTOS.icf ccfg.c display.c main_nortos.c splash_image.c
