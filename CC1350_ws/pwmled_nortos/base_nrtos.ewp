# IAR project base_nrtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DeviceFamily_CC13X0
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/nortos; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/nortos/posix
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  ILINK.IlinkOutputFile: pwmled2.out
  ILINK.IlinkIcfFile: $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/examples/nortos/CC1350_LAUNCHXL_433/drivers/pwmled2/iar/CC1350_LAUNCHXL_433_NoRTOS.icf
  ILINK.IlinkExtraOptions: $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m3/grlib.a; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m3/spiffs_cc26xx.a; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/nortos/lib/nortos_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/devices/cc13x0/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group pwmled2/Documentation
    $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/boards/CC1350_LAUNCHXL_433/: Board.html
    ./: README.html README.md
  group pwmled2/Header files
    ./: Board.h CC1350_LAUNCHXL_433.h
  group pwmled2/Source files
    ./: CC1350_LAUNCHXL_433.c CC1350_LAUNCHXL_433_fxns.c CC1350_LAUNCHXL_433_NoRTOS.icf ccfg.c demo.c main_nortos.c matrix.c matrix.h pca_chl.c pca_chl.h pwmled2.c
    ../../chl2020/刘冰/清华课题/PCAcode/Matrix_hub-master/version/: state.h
